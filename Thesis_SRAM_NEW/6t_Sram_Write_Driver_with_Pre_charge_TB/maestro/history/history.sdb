<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>May 12 14:07:01 2026</timestamp>
			<uuid>{acfa7b9a-106a-40f0-b242-e500c92f0e9e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/elshazlio@auc.egy/cadence/Thesis_SRAM_NEW/6t_Sram_Write_Driver_with_Pre_charge_TB/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/home/elshazlio@auc.egy/simulation/Thesis_SRAM_NEW/6t_Sram_Write_Driver_with_Pre_charge_TB/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Thesis_SRAM_NEW/6t_Sram_Write_Driver_with_Pre_charge_TB/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
